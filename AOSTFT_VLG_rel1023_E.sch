v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
L 4 30 -80 30 -40 {}
L 4 40 -80 40 -40 {}
L 4 40 -80 60 -80 {}
L 4 40 -40 60 -40 {}
L 4 60 -110 60 -80 {}
L 4 60 -40 60 -15 {}
L 4 -15 -60 30 -60 {}
P 4 4 40 -80 45 -85 45 -75 40 -80 {}
C {devices/iopin.sym} 60 -110 0 0 {name=p1 lab=D}
C {devices/iopin.sym} 60 -15 0 0 {name=p2 lab=S}
C {devices/iopin.sym} -15 -60 0 1 {name=p3 lab=G}
